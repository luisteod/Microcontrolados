# Keil uVision project exemplo.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exemplo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group New Group
    ./: teclado.c startup.s utils.s adc.c gpio.c lcd.c main.c motor.c motor_dc.c uart.c adc.h gpio.h lcd.h motor.h motor_dc.h system_global_definitions.h teclado.h tm4c1294ncpdt.h uart.h
